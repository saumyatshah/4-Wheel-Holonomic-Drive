# Keil uVision project 4_w_Omni_Drive.uvprojx, settings and files
target stm32f407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 4_w_Omni_Drive +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./: main.cpp
    ./stm32f4/: common.cpp GPIO.cpp I2C.cpp LCD.cpp RCC.cpp SPI.cpp TIMER.cpp USART.cpp
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
